# KOMPAS-3D part (ZARDP 032.200.30.P.m3d)

Model tree:
1. Операция без истории:1

Texts:
  ООО ИК Энерпред-Ярдос